Commit message: my_car.urdf

File: urdf/my_car.urdf (robot description, URDF)
Before this commit: robot two_wheel_car, 7 links, 6 joints
Joints:
- joint caster_housing_joint: axis 0 0 1 -> 0 0 -1
- joint left_wheel_joint: axis 0 0 1 -> 0 0 -1
- joint right_wheel_joint: axis 0 0 1 -> 0 0 -1
